# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\System;.\src;.\Hardware
  group System
    ./System/: boebot.c Boebot.h
  group Hardware
    ./Hardware/: motor.c motor.h uart.c uart.h ultrasonic.c ultrasonic.h
  group src
    ./src/: main.c
    ./: tsc230.h
